include u-boot-fslc.inc

PV = "v2015.04+git${SRCPV}"

SRCREV = "c42b934258af355048e7bcee35ec8c671d7dc765"
SRCBRANCH = "imx_v2015.04_4.1.15_1.0.0_ga"
